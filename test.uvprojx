# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group headers
    ./headers/: test.h
  group sources
    ./sources/: test.c
